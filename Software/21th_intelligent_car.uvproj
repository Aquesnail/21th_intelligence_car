# Keil uVision project 21th_intelligent_car.uvproj, settings and files
target 21th_intelligent_car (MCS-251)
  device: STC32G144K246-32Bit Series STC
  cpu: IRAM(0-0x3FFF) XRAM(0x10000-0x2FFFF) IROM(0xFC2800-0xFFFFFF) CLOCK(35000000)
  output: 21th_intelligent_car +hex
  link misc: REMOVEUNUSED
  group User Sources
    ./Sources/User/: FreeRTOSConfig.h application.c application.h params.c params.h config.h main.c
  group FreeRTOS
    ./Sources/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./Sources/FreeRTOS/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.h stream_buffer.h task.h timers.h stdint.readme
  group FreeRTOS_Port
    ./Sources/FreeRTOS/portable/MemMang/: heap_1.c
    ./Sources/FreeRTOS/portable/STC32G12K128/: portasm.h portmacro.h port_rtos.c
  group Comm
    ./Sources/Comm/: ai_usb.h DEF.H stc32g144k246_def.h
  group Drivers
    ./Sources/Drivers/: iap.c iap.h stc_usb_cdc_32.LIB stc_usb_hid_32.LIB STC32_DSP32_LARGE.LIB stc32_fpmu_large.lib STC32_MDU32_LARGE.LIB port.c port.h
