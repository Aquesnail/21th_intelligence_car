# Keil uVision project 21th_intelligent_car_bk1.uvproj, settings and files
target 21th_intelligent_car (MCS-251)
  device: STC32G144K246-32Bit Series STC
  cpu: IRAM(0-0x3FFF) XRAM(0x10000-0x2FFFF) IROM(0xFC2800-0xFFFFFF) CLOCK(35000000)
  output: 21th_intelligent_car +hex
  link misc: REMOVEUNUSED, NOOVERLAY
  group AiCube
    ./Sources/: main.c port.c clock.c lvr.c
